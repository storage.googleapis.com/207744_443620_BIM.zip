Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-31T16:38:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 31 16:38:32 2021 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{C92CC499-139B-48D5-9414-63290A1F1455}\ifc * Database version: 5507 * Database creation date: Tue Aug 31 16:38:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 31 16:38:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 31 16:38:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowController: 443620 Shut-off connector, DN20, L=31, H=28, 443620(2021):443620 Shut-off connector, DN20, L=31, H=28:341176
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 33.9994 mm; NominalHeight: 49.0719 mm; NominalWidth: 101.284 mm
Type - General - Author: BIMstone; BIMObjectName: 443620(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: TE_60_60_40_78; Uniclass2015Description: Shut-off pipe sections; Uniclass2015Reference: TE_60_60_40_78; Version: 1; VersionDate: 04/08/2021
Type - Green Building Properties - Customs Code: 84818039; EAN Number: 6414150098062; EN Standard: EN 215; LVI Number: 4032039
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/443620; Catalog Drawing URL: http://static.oras.com/catdrw/443620; Dimension Drawing URL: http://static.oras.com/dimdrw/443620; FDV Document URL: http://www.oras.com/datasheet/443620/en/fdv; Group: RadiatorValve; Manufacturer: Oras; Model: 443620 Shut-off connector, DN20, L=31, H=28; Name_en: 443620 Shut-off connector, DN20, L=31, H=28; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.195 kg; Product Code: 443620; Product Datasheet: http://www.oras.com/datasheet/443620/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/443620; Product URL: http://static.oras.com/443620; Technical DataSheet URL: http://www.oras.com/datasheet/443620/en; Type Name: 443620 Shut-off connector, DN20, L=31, H=28
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection: InternalThread; Connection Size: G3/4; DN Size: DN20; Installation and Maintenance: http://static.oras.com/manual/443620; Max. Hot Water Supply: 120 kg/K/s3
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Technical room; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 443620(2021); Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 443620; Name: 443620 Shut-off connector, DN20, L=31, H=28; ReplacementCost: n/a; Shape: Sculptured; Size: 280x190x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.00607124 m2; InletConnectionSize: 20 mm; InletDistance: 150 mm; InletRadius: 10 mm; Volume: 0.0000884271 m3
Identity Data - Mark: 27
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 443620(2021): 443620 Shut-off connector, DN20, L=31, H=28; Family and Type: 443620(2021): 443620 Shut-off connector, DN20, L=31, H=28; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 443620(2021): 443620 Shut-off connector, DN20, L=31, H=28; Type Id: 443620(2021): 443620 Shut-off connector, DN20, L=31, H=28; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
